<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\XiangRui_STM8L15x_Library.ewp</path>
  </project>
  <batchBuild/>
</workspace>


