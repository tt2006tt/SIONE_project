# Keil uVision project STM32F0 Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: .\User;.\Library\CMSIS\Include;.\Library\STM32F0xx_StdPeriph_Driver\inc;.\uart;.\ADSP9960
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./Library/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ./User/: system_stm32f0xx.c stm32f0xx_it.c gesture.c
  group STM32F0xx_StdPeriph_Driver
    ./Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_pwr.c
  group uart
    ./uart/: uart.c
  group ADSP9960
    ./ADSP9960/: ADSP9960_platform.c SparkFun_ADSP9960.c
