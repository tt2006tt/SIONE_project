# Keil uVision project 8266_air.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7320 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: 8266_air +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./app/: main.c voc_init.c
